## west.yml
```yaml
manifest:
  projects:
    - name: zephyr
      path: zephyr
      import: true
  self:
    path: .
```
